# Keil uVision project GD32F330.uvprojx, settings and files
target GD32F330 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F330C8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F330 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F330
  c include: .\Application;.\Firmware\CMSIS;.\Firmware\GD32F3x0_standard_peripheral\Include;.\Firmware\CMSIS\GD\GD32F3x0\Include;.\BSP\LED;.\BSP\ADC_KEY;.\BSP\USART;.\BSP\AT24C02;.\BSP\W25Q64;.\BSP\ADC;.\BSP\EXTI;.\BSP\TIMER;.\BSP\PWM;.\BSP\DMA;.\BSP\FMC;.\BSP\ENCODER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ./Application/: main.c gd32f3x0_it.c systick.c
  group BSP
    ./BSP/LED/: led.c
    ./BSP/ADC_KEY/: adc_key.c
    ./BSP/USART/: usart.c
    ./BSP/AT24C02/: at24c02.c
    ./BSP/W25Q64/: w25q64.c
    ./BSP/ADC/: adc.c
    ./BSP/EXTI/: exti.c
    ./BSP/TIMER/: timer.c
    ./BSP/PWM/: pwm.c
    ./BSP/DMA/: dma.c
    ./BSP/FMC/: fmc.c
    ./BSP/ENCODER/: encoder.c
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group GD32F3x0_Peripherals
    ./Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Startup
    ./Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
